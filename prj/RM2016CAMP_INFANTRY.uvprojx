# Keil uVision project RM2016CAMP_INFANTRY.uvprojx, settings and files
target RM2016CAMP_INFANTRY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2016CAMP_INFANTRY
  AfterMake: fromelf.exe  --bin -o ../bin/RM2016CAMP_INFANTRY.bin ./Objects/RM2016CAMP_INFANTRY.axf
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app;..\bsp;..\dep;..\imu;..\lib;..\usr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: Can1Task.c Can2Task.c InputTask.c OutputTask.c RelayTask.c
  group bsp
    ../bsp/: bsp.c can1.c can2.c cbus.c crc8.c crc16.c crc32.c dbus.c delay.c encoder.c fifo.c led.c motor.c pid.c pwm.c QuadEncoder.c ramp.c timer.c usart1.c usart3.c
  group lib
    ../lib/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c startup_stm32f4xx.s
  group usr
    ../usr/: main.c
